# Keil uVision project DMA_CopyFromFlashToMemory_Init.uvprojx, settings and files
target DMA_CopyFromFlashToMemory_Init (6160000::V6.16::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DMA_CopyFromFlashToMemory_Init
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_CACHE_ENABLE=1 EXTERNAL_CLOCK_VALUE=12288000 HSE_STARTUP_TIMEOUT=100 HSE_VALUE=8000000 HSI_VALUE=16000000 INSTRUCTION_CACHE_ENABLE=1 LSE_STARTUP_TIMEOUT=5000 LSE_VALUE=32768 LSI_VALUE=32000 PREFETCH_ENABLE=0 VDD_VALUE=3300
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\stm32g071.sct
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/Inc/: stm32g0xx_it.h
  group STM32CubeMX:Project
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, Device:STM32Cube LL:Common 1.4.0, Device:STM32Cube LL:DMA 1.4.0, Device:STM32Cube LL:GPIO 1.4.0, Device:STM32Cube LL:PWR 1.4.0, Device:STM32Cube LL:RCC 1.4.0, Device:STM32Cube LL:UTILS 1.4.0, Device:Startup 1.4.0
