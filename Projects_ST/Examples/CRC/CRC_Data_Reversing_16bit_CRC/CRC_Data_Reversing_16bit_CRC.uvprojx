# Keil uVision project CRC_Data_Reversing_16bit_CRC.uvprojx, settings and files
target CRC_Data_Reversing_16bit_CRC (6160000::V6.16::ARMCLANG)
  device: STM32G071RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.1-dev1
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CRC_Data_Reversing_16bit_CRC
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\stm32g071.sct
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/Src/: main.c stm32g0xx_it.c
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/Inc/: stm32g0xx_it.h
  group STM32CubeMX:Project
    ./RTE/Device/STM32G071RBTx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, Board Support:Drivers:Basic I/O 1.2.1, Device:STM32Cube HAL:CRC 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:EXTI 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:UART 1.4.0, Device:Startup 1.4.0
